# Keil uVision project Smpl_LibSiren7EnDec.uvproj, settings and files
target Smpl_LibSiren7EnDec (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_LibSiren7EnDec
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1
  c define: SEMIHOST
  c include: ..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\NUVOTON\ISD91xx;..\..\..\..\NuvotonPlatform_Keil\Include\;..\..\..\include\driver;..\..\..\include\lib
  memory RVCT4: ROM 0x0 size 0x233ff
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='boot_ISD9xx.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/: boot_ISD9xx.c system_ISD9xx.c
  group Source files
    ./: AudioDatal.s Smpl_LibSiren7EnDec.c
  group Library files
    ../../../Lib/: SemiHost_Keil.lib LibSiren7.lib
  group Driver
    ../../../Src/Driver/: DrvSYS.c DrvUART.c DrvPDMA.c DrvDPWM.c DrvGPIO.c
    ../../../Src/: retarget.c
