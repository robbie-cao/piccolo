# Keil uVision project Smpl_LDROM.uvproj, settings and files
target Smpl_LDROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_LDROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output "..\..\..\..\..\software\binfiles\@L.bin"
  c flags: OneElfS=1
  c define: VERILOG_VALIDATION,SEMIHOST
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='boot.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler --callgraph
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c
  group Source files
    ./: LoaderImage.s Smpl_LDROM.c boot.c
  group Library files
    ../../../Src/Driver/: retarget.c DrvFMC.c DrvGPIO.c DrvSYS.c DrvUART.c
    ../../../Lib/: SemiHost_Keil.lib
