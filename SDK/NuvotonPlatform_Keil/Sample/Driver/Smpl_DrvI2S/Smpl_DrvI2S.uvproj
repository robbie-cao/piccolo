# Keil uVision project Smpl_DrvI2S.uvproj, settings and files
target Smpl_DrvI2S (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_DrvI2S
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c define: SEMIHOST
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map  --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c boot_ISD9xx.c
  group Source files
    ./: Smpl_DrvI2S.c WAU8822Setup.c
  group Library files
    ../../../Src/Driver/: retarget.c DrvI2C.c DrvI2S.c DrvGPIO.c DrvSYS.c DrvUART.c
    ../../../Lib/: SemiHost_Keil.lib
