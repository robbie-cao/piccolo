# Keil uVision project Smpl_DrvRTC.uvproj, settings and files
target Smpl_DrvRTC (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: Smpl_DrvRTC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output "..\..\..\..\binfiles\@L.bin"
  c flags: Optim=1 OneElfS=1
  c define: SEMIHOST
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='boot.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler --callgraph
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c boot_ISD9xx.c
  group Source files
    ./: Smpl_DrvRTC.c
  group Library files
    ../../../Src/Driver/: retarget.c DrvGPIO.c DrvRTC.c DrvSYS.c DrvUART.c DrvPMU.c
  group Lib
    ../../../Lib/: SemiHost_Keil.lib
