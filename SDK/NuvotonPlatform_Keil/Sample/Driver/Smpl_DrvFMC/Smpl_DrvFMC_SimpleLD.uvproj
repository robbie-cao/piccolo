# Keil uVision project Smpl_DrvFMC_SimpleLD.uvproj, settings and files
target Smpl_DrvFMC_SimpleLD (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_DrvFMC_SimpleLD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: SEMIHOST
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_ISD91xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/startup/arm/: startup_ISD91xx.s
  group Source files
    ./: Smpl_DrvFMC_SimpleLD.c
  group Library files
    ../../../Src/Driver/: retarget.c DrvFMC.c DrvSYS.c DrvUART.c
    ../../../Lib/: SemiHost_Keil.lib
target Smpl_DrvFMC_SimpleLD_semihost (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_DrvFMC_SimpleLD_semihost
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: SEMIHOST
  c include: ..\..\..\..\CMSIS\CM0CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  asm define: SEMIHOST
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
