# Keil uVision project Smpl_DrvCRC.uvproj, settings and files
target Smpl_DrvCRC (ARM-ADS)
  device: NUC1XX Nuvoton
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_DrvCRC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output "..\..\..\..\binfiles\@L.bin"
  c flags: Optim=1 OneElfS=1
  c define: SEMIHOST
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: --map --first='boot.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler --callgraph
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c boot_ISD9xx.c
  group Source files
    ./: Smpl_DrvCRC.c
  group Library files
    ../../../Src/Driver/: DrvSPI.c DrvSYS.c DrvUART.c DrvGPIO.c retarget.c DrvCRC.c
  group Lib
    ../../../Lib/: SemiHost_Keil.lib
target Smpl_DrvCRC_semihost (ARM-ADS)
  device: NUC1XX Nuvoton
  cpu: as above
  output: Smpl_DrvCRC_semihost
  AfterMake: as above
  c flags: Optim=1 OneElfS=1
  c define: SEMIHOST
  c include: ..\..\..\..\CMSIS\CM0CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: as above
