# Keil uVision project Smpl_RecPlay.uvproj, settings and files
target Smpl_RecPlay (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_RecPlay +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  c flags: Optim=4
  c misc: --min_array_alignment=4 --pointer_alignment=4
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\..\NuvotonPlatform_Keil\Sample\Demo\Smpl_RecPlay\src;..\..\..\..\NuvotonPlatform_Keil\Include\Lib;..\..\..\..\NuvotonPlatform_Keil\Include\Lib\Demo;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x233ff
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_ISD9xx.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/: startup_ISD9xx.c system_ISD9xx.c
  group Source files
    ../../../Sample/Demo/Smpl_RecPlay/src/: main.c audfile.c isd9_audout.c isd9_audin.c ffx_io_flash.c menu.c
    ./src/: hw.c lcd_uc1601.c
  group Lib
    ../../../Lib/Demo/: libVPB.lib libButtons.lib libCapButtons.lib libFFX.lib libFlash.lib libMIC.lib libSpeaker.lib
    ../../../Lib/: libSPIFlash.lib LibSiren7.lib
  group Driver
    ../../../Src/Driver/: DrvSYS.c DrvGPIO.c DrvPDMA.c
