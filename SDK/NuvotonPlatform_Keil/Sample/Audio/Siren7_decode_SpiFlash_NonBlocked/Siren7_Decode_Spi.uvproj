# Keil uVision project Siren7_Decode_Spi.uvproj, settings and files
target Debug (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: S7_Decode_SpiFlash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: SEMIHOST
  c include: inc;.\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver;ASR\inc,Fea\inc,Vite\inc
  memory RVCT4: ROM 0x0 size 0x233ff
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='boot_ISD9xx.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c
  group Source files
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/: boot_ISD9xx.c
    ./: main.c InitSpiFlash.c PlaySpiSiren7.c
  group Lib files
    ../../../Src/Driver/: retarget.c DrvSYS.c DrvUART.c DrvDPWM.c DrvGPIO.c DrvPDMA.c DrvADC.c DrvTimer.c
    ../../../Lib/: SemiHost_Keil.lib libSPIFlash.lib LibSiren7.lib
