# Keil uVision project MIC_SPK.uvproj, settings and files
target Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MIC_SPK_Wrap
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: SEMIHOST
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x233ff
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_ISD91xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/startup/arm/: startup_ISD91xx.s
  group Source files
    ./: PlayPCM.c RecordPCM.c MIC_SPK.c
  group Library files
    ../../../Src/Driver/: retarget.c DrvFMC.c DrvSYS.c DrvUART.c DrvADC.c DrvPDMA.c DrvGPIO.c DrvDPWM.c
    ../../../Lib/: SemiHost_Keil.lib
