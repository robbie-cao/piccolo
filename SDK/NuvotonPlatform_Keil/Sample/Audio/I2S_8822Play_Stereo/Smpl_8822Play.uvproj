# Keil uVision project Smpl_8822Play.uvproj, settings and files
target Debug (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: I2S_8822Play
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c define: SEMIHOST
  c include: .;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map  --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c boot_ISD9xx.c
  group Source files
    ./: WAU8822Setup.c PDMA_I2S.c I2S_8822Play.c AudioDatal.s
  group Library files
    ../../../Src/Driver/: retarget.c DrvI2C.c DrvI2S.c DrvGPIO.c DrvSYS.c DrvUART.c DrvPDMA.c
    ../../../Lib/: SemiHost_Keil.lib
