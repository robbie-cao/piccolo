# Keil uVision project RecordPlayS7_SD.uvproj, settings and files
target Debug (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: G722Decode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 oTime=1 OneElfS=1
  c include: inc;.\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\..\Include;..\..\..\Include\Driver;ASR\inc,Fea\inc,Vite\inc
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='boot_ISD9xx.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c
  group Source files
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/: boot_ISD9xx.c
    ./: main.c PlayS7_SD.c SDaccess.c RecordS7_SD.c
  group Lib files
    ../../../Src/Driver/: retarget.c DrvSYS.c DrvUART.c DrvDPWM.c DrvGPIO.c DrvPDMA.c DrvADC.c DrvTimer.c DrvSDCard.c DrvSPI.c
    ../../../Lib/: SemiHost_Keil.lib LibSiren7.lib
