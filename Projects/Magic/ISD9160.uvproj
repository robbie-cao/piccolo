# Keil uVision project ISD9160.uvproj, settings and files
target Common (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: Magic +hex
  AfterMake: fromelf --bin ".\Common\Obj\@L.axf" --output ".\Common\Exe\@L.bin"
  AfterMake: fromelf --text -c -s ".\Common\Obj\@L.axf" --output ".\Common\Exe\@L.txt"
  c flags: oTime=1 OneElfS=1 wLevel=2
  c define: LOG_LEVEL_DEBUG
  c include: .;..\..\Source\utils;..\..\Source\inc;..\..\Source\osal;..\..\SDK\CMSIS\CM0\CoreSupport;..\..\SDK\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\SDK\NuvotonPlatform_Keil\Include;..\..\SDK\NuvotonPlatform_Keil\Include\Driver;..\..\SDK\NuvotonPlatform_Keil\Include\Lib;..\..\SDK\NuvotonPlatform_Keil\Include\Lib\Demo;..\..\SDK\NuvotonPlatform_Keil\Include\System;
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='boot_ISD9xx.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../SDK/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../SDK/CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/: boot_ISD9xx.c system_ISD9xx.c
  group Source files
    ../../Source/isd9160/: PM.c SpiFlash.c main.c mainOsal.c PlaySpiSiren7.c I2C.c OP.c Reg.c UART.c GPIO.c SYS.c Flash.c ATC.c
  group Target files
    ../../SDK/NuvotonPlatform_Keil/Src/Driver/: retarget.c
  group Drv files
    ../../SDK/NuvotonPlatform_Keil/Src/Driver/: DrvPMU.c DrvPDMA.c DrvI2C.c DrvDPWM.c DrvTimer.c DrvSYS.c DrvUART.c DrvGPIO.c DrvADC.c
  group Lib files
    ../../SDK/NuvotonPlatform_Keil/Lib/: SemiHost_Keil.lib libSPIFlash.lib LibSiren7.lib
  group OSAL files
    ../../Source/osal/: OSAL_Timers.c OSAL.c OSAL_BufMgr.c OSAL_CbTimer.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c
  group Utils files
    ../../Source/utils/: parser.c
target Debug (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: as above
  output: Magic +hex
  AfterMake: fromelf --bin ".\AudDebug\Obj\@L.axf" --output ".\AudDebug\Exe\@L.bin"
  AfterMake: fromelf --text -c -s ".\AudDebug\Obj\@L.axf" --output ".\AudDebug\Exe\@L.txt"
  c flags: oTime=1 OneElfS=1 wLevel=2
  c define: LOG_LEVEL_DEBUG OSAL_CBTIMER_NUM_TASKS=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: as above
target Release (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: as above
  output: Magic +hex
  AfterMake: fromelf --bin ".\AudRelease\Obj\@L.axf" --output ".\AudCommon\Exe\@L.bin"
  AfterMake: fromelf --text -c -s ".\AudRelease\Obj\@L.axf" --output ".\AudRelease\Exe\@L.txt"
  c flags: oTime=1 OneElfS=1 wLevel=2
  c define: LOG_LEVEL_WARN
  c include: as above
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: as above
