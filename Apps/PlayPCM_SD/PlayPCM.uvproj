# Keil uVision project PlayPCM.uvproj, settings and files
target Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: PlayPCM_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: SEMIHOST
  c include: .\;..\..\SDK\CMSIS\CM0\CoreSupport;..\..\SDK\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\SDK\NuvotonPlatform_Keil\Include;..\..\SDK\NuvotonPlatform_Keil\Include\Driver
  memory RVCT4: ROM 0x0 size 0x233ff
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_ISD91xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../SDK/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../SDK/CMSIS/CM0/DeviceSupport/NUVOTON/ISD91xx/: system_ISD9xx.c
    ../../SDK/CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/startup/arm/: startup_ISD91xx.s
  group Source files
    ./: PlayPCM.c SDaccess.c
  group Library files
    ../../SDK/NuvotonPlatform_Keil/Src/Driver/: retarget.c DrvSYS.c DrvUART.c DrvPDMA.c DrvDPWM.c DrvTimer.c DrvSDCard.c DrvSPI.c DrvGPIO.c
    ../../SDK/NuvotonPlatform_Keil/Lib/: SemiHost_Keil.lib
